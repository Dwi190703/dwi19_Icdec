v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/dwi/opamp/mag/pmoscs.sym} -690 -400 0 0 {name=x1}
C {/home/dwi/opamp/mag/nmoscs.sym} -690 -230 0 0 {name=x2}
C {/home/dwi/opamp/mag/nmos2.sym} -200 -230 2 0 {name=x3}
C {devices/lab_pin.sym} -540 -430 2 0 {name=p1 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -360 -380 0 0 {name=p2 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -350 -250 0 0 {name=p3 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -540 -200 2 0 {name=p4 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -540 -220 2 0 {name=p5 sig_type=std_logic lab=rs}
C {devices/lab_pin.sym} -60 -400 2 0 {name=p6 sig_type=std_logic lab=vip}
C {devices/lab_pin.sym} -60 -380 2 0 {name=p7 sig_type=std_logic lab=vin}
C {/home/dwi/opamp/mag/pmos2.sym} -210 -410 2 0 {name=x4}
C {devices/iopin.sym} -890 -420 0 0 {name=p8 lab=vdd}
C {devices/iopin.sym} -890 -390 0 0 {name=p9 lab=gnd}
C {devices/iopin.sym} -890 -360 0 0 {name=p10 lab=out}
C {devices/iopin.sym} -890 -330 0 0 {name=p11 lab=vin}
C {devices/iopin.sym} -890 -300 0 0 {name=p12 lab=vip}
C {devices/iopin.sym} -890 -270 0 0 {name=p13 lab=rs}
C {devices/lab_pin.sym} -540 -410 2 0 {name=p15 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} -540 -390 2 0 {name=p16 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} -540 -370 2 0 {name=p17 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} -360 -400 0 0 {name=p18 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} -360 -420 0 0 {name=p19 sig_type=std_logic lab=out}
C {devices/lab_pin.sym} -360 -440 0 0 {name=p20 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} -350 -230 0 0 {name=p21 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} -350 -210 0 0 {name=p22 sig_type=std_logic lab=out}
C {devices/lab_pin.sym} -540 -240 2 0 {name=p23 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} -540 -260 2 0 {name=p24 sig_type=std_logic lab=net1}
